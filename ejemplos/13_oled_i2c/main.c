/*
 * 13_oled_i2c/main.c - Pantalla OLED SSD1306 128x64 por I2C (ESP-IDF)
 * Monitoria: Introduccion al ESP32 - Intro. Ing. Electronica (UNAL)
 * Entorno: VS Code + extension ESP-IDF (IDF v5.3+ / v6.x)
 * Concepto: bus I2C maestro, buffer de pixeles, fuente 5x7, comandos SSD1306
 * Montaje: OLED VCC a 3V3, GND a GND, SDA y SCL segun la placa
 * Direccion: 0x3C (algunas pantallas usan 0x3D)
 *
 * No se necesita ningun componente externo: aqui estan los comandos del
 * SSD1306 y una fuente minima para entender que hace una libreria grafica.
 *
 * Si el enlazado no encuentra i2c_new_master_bus, agrega REQUIRES esp_driver_i2c
 * en main/CMakeLists.txt.
 *
 * OJO: el OLED es de 3.3 V. No lo alimentes con 5 V.
 */

#include <stdio.h>
#include <string.h>
#include "freertos/FreeRTOS.h"
#include "freertos/task.h"
#include "driver/i2c_master.h"

// ---------- PINES DEL BUS I2C ----------
#if defined(HELTEC_V3)
#define PIN_SDA          17    // Heltec V3: I2C de la pantalla interna
#define PIN_SCL          18
#elif defined(CONFIG_IDF_TARGET_ESP32C6)
#define PIN_SDA          6     // ESP32-C6 DevKitC-1
#define PIN_SCL          7
#elif defined(CONFIG_IDF_TARGET_ESP32S3)
#define PIN_SDA          8     // ESP32-S3 DevKit
#define PIN_SCL          9
#else
#define PIN_SDA          21    // ESP32-WROOM-32
#define PIN_SCL          22
#endif

#define DIR_OLED         0x3C
#define FREC_I2C_HZ      100000
#define ANCHO_PX         128
#define ALTURA_PX        64
#define PAGINAS          8              // 64 pixeles / 8 bits por pagina

static i2c_master_dev_handle_t oled = NULL;

// Buffer de 8 paginas x 128 columnas. Cada bit es un pixel.
static uint8_t buffer[PAGINAS][ANCHO_PX];

// Fuente 5x7 para ASCII imprimible (0x20 a 0x7E).
// Cada byte es una columna; el bit 0 es la fila superior.
static const uint8_t fuente[95][5] = {
    {0x00,0x00,0x00,0x00,0x00}, // espacio
    {0x00,0x00,0x5F,0x00,0x00}, // !
    {0x00,0x07,0x00,0x07,0x00}, // "
    {0x14,0x7F,0x14,0x7F,0x14}, // #
    {0x24,0x2A,0x7F,0x2A,0x12}, // $
    {0x23,0x13,0x08,0x64,0x62}, // %
    {0x36,0x49,0x55,0x22,0x50}, // &
    {0x00,0x05,0x03,0x00,0x00}, // '
    {0x00,0x1C,0x22,0x41,0x00}, // (
    {0x00,0x41,0x22,0x1C,0x00}, // )
    {0x14,0x08,0x3E,0x08,0x14}, // *
    {0x08,0x08,0x3E,0x08,0x08}, // +
    {0x00,0x50,0x30,0x00,0x00}, // ,
    {0x08,0x08,0x08,0x08,0x08}, // -
    {0x00,0x60,0x60,0x00,0x00}, // .
    {0x20,0x10,0x08,0x04,0x02}, // /
    {0x3E,0x51,0x49,0x45,0x3E}, // 0
    {0x00,0x42,0x7F,0x40,0x00}, // 1
    {0x42,0x61,0x51,0x49,0x46}, // 2
    {0x21,0x41,0x45,0x4B,0x31}, // 3
    {0x18,0x14,0x12,0x7F,0x10}, // 4
    {0x27,0x45,0x45,0x45,0x39}, // 5
    {0x3C,0x4A,0x49,0x49,0x30}, // 6
    {0x01,0x71,0x09,0x05,0x03}, // 7
    {0x36,0x49,0x49,0x49,0x36}, // 8
    {0x06,0x49,0x49,0x29,0x1E}, // 9
    {0x00,0x36,0x36,0x00,0x00}, // :
    {0x00,0x56,0x36,0x00,0x00}, // ;
    {0x08,0x14,0x22,0x41,0x00}, // <
    {0x14,0x14,0x14,0x14,0x14}, // =
    {0x00,0x41,0x22,0x14,0x08}, // >
    {0x02,0x01,0x51,0x09,0x06}, // ?
    {0x32,0x49,0x79,0x41,0x3E}, // @
    {0x7F,0x08,0x08,0x08,0x7F}, // A
    {0x7F,0x49,0x49,0x49,0x36}, // B
    {0x3E,0x41,0x41,0x41,0x22}, // C
    {0x7F,0x41,0x41,0x22,0x1C}, // D
    {0x7F,0x49,0x49,0x49,0x41}, // E
    {0x7F,0x09,0x09,0x09,0x01}, // F
    {0x3E,0x41,0x49,0x49,0x7A}, // G
    {0x7F,0x08,0x08,0x08,0x7F}, // H
    {0x00,0x41,0x7F,0x41,0x00}, // I
    {0x20,0x40,0x41,0x3F,0x01}, // J
    {0x7F,0x08,0x14,0x22,0x41}, // K
    {0x7F,0x40,0x40,0x40,0x40}, // L
    {0x7F,0x02,0x0C,0x02,0x7F}, // M
    {0x7F,0x04,0x08,0x10,0x7F}, // N
    {0x3E,0x41,0x41,0x41,0x3E}, // O
    {0x7F,0x09,0x09,0x09,0x06}, // P
    {0x3E,0x41,0x51,0x21,0x5E}, // Q
    {0x7F,0x09,0x19,0x29,0x46}, // R
    {0x46,0x49,0x49,0x49,0x31}, // S
    {0x01,0x01,0x7F,0x01,0x01}, // T
    {0x3F,0x40,0x40,0x40,0x3F}, // U
    {0x1F,0x20,0x40,0x20,0x1F}, // V
    {0x3F,0x40,0x38,0x40,0x3F}, // W
    {0x63,0x14,0x08,0x14,0x63}, // X
    {0x07,0x08,0x70,0x08,0x07}, // Y
    {0x61,0x51,0x49,0x45,0x43}, // Z
    {0x00,0x7F,0x41,0x41,0x00}, // [
    {0x02,0x04,0x08,0x10,0x20}, // backslash
    {0x00,0x41,0x41,0x7F,0x00}, // ]
    {0x04,0x02,0x01,0x02,0x04}, // ^
    {0x40,0x40,0x40,0x40,0x40}, // _
    {0x00,0x01,0x02,0x04,0x00}, // `
    {0x20,0x54,0x54,0x54,0x78}, // a
    {0x7F,0x48,0x44,0x44,0x38}, // b
    {0x38,0x44,0x44,0x44,0x20}, // c
    {0x38,0x44,0x44,0x48,0x7F}, // d
    {0x38,0x54,0x54,0x54,0x18}, // e
    {0x08,0x7E,0x09,0x01,0x02}, // f
    {0x0C,0x52,0x52,0x52,0x3E}, // g
    {0x7F,0x08,0x04,0x04,0x78}, // h
    {0x00,0x44,0x7D,0x40,0x00}, // i
    {0x20,0x40,0x44,0x3D,0x00}, // j
    {0x7F,0x10,0x28,0x44,0x00}, // k
    {0x00,0x41,0x7F,0x40,0x00}, // l
    {0x7C,0x04,0x18,0x04,0x78}, // m
    {0x7F,0x08,0x10,0x08,0x7F}, // n
    {0x38,0x44,0x44,0x44,0x38}, // o
    {0x7C,0x14,0x14,0x14,0x08}, // p
    {0x08,0x14,0x14,0x18,0x7C}, // q
    {0x7F,0x08,0x04,0x04,0x08}, // r
    {0x48,0x54,0x54,0x54,0x20}, // s
    {0x04,0x3F,0x44,0x40,0x20}, // t
    {0x3C,0x40,0x40,0x20,0x7C}, // u
    {0x1C,0x20,0x40,0x20,0x1C}, // v
    {0x3C,0x40,0x30,0x40,0x3C}, // w
    {0x44,0x28,0x10,0x28,0x44}, // x
    {0x0C,0x50,0x50,0x50,0x3C}, // y
    {0x44,0x64,0x54,0x4C,0x44}, // z
    {0x00,0x08,0x36,0x41,0x00}, // {
    {0x00,0x00,0x7F,0x00,0x00}, // |
    {0x00,0x41,0x36,0x08,0x00}, // }
    {0x08,0x08,0x2A,0x1C,0x08}, // ~
};

// Envia un comando al SSD1306. El primer byte 0x00 dice "viene un comando".
static void oled_comando(uint8_t comando)
{
    uint8_t buf[2] = { 0x00, comando };
    i2c_master_transmit(oled, buf, 2, 100);
}

// Envia 128 bytes de datos. El primer byte 0x40 dice "vienen pixeles".
static void oled_fila(uint8_t pagina)
{
    uint8_t buf[1 + ANCHO_PX];
    buf[0] = 0x40;
    memcpy(&buf[1], buffer[pagina], ANCHO_PX);
    i2c_master_transmit(oled, buf, sizeof(buf), 100);
}

static void oled_inicializar(void)
{
    oled_comando(0xAE);              // apaga la pantalla mientras se configura
    oled_comando(0xD5); oled_comando(0x80);  // reloj por defecto
    oled_comando(0xA8); oled_comando(0x3F);  // 64 filas (ALTURA_PX - 1)
    oled_comando(0xD3); oled_comando(0x00);  // sin desplazamiento
    oled_comando(0x40);              // empieza en la linea 0
    oled_comando(0x8D); oled_comando(0x14);  // enciende la bomba de carga
    oled_comando(0x20); oled_comando(0x00);  // direccionamiento horizontal
    oled_comando(0xA1);              // invierte el eje X
    oled_comando(0xC8);              // invierte el eje Y
    oled_comando(0xDA); oled_comando(0x12);  // configuracion de pines COM
    oled_comando(0x81); oled_comando(0x8F);  // contraste
    oled_comando(0xD9); oled_comando(0xF1);  // tiempos de carga
    oled_comando(0xDB); oled_comando(0x40);  // nivel VCOMH
    oled_comando(0xA4);              // muestra el contenido del buffer
    oled_comando(0xA6);              // 1 = pixel encendido
    oled_comando(0xAF);              // enciende la pantalla
}

static void oled_borrar(void)
{
    memset(buffer, 0, sizeof(buffer));
}

// Dibuja un caracter en columna de caracter (0..20) y pagina (0..7)
static void oled_caracter(char c, uint8_t columna, uint8_t pagina)
{
    uint8_t indice = (c >= 0x20 && c <= 0x7E) ? (uint8_t)(c - 0x20) : 0;

    for (uint8_t x = 0; x < 5; x++) {
        uint8_t columna_bits = fuente[indice][x];
        for (uint8_t y = 0; y < 7; y++) {
            if (columna_bits & (1 << y)) {
                buffer[pagina][columna * 6 + x] |= (1 << y);
            }
        }
    }
}

static void oled_texto(const char *texto, uint8_t columna, uint8_t pagina)
{
    size_t longitud = strlen(texto);
    for (size_t i = 0; i < longitud && i < 21; i++) {
        oled_caracter(texto[i], columna + (uint8_t)i, pagina);
    }
}

// Envia todo el buffer al OLED
static void oled_mostrar(void)
{
    for (uint8_t pagina = 0; pagina < PAGINAS; pagina++) {
        oled_comando(0xB0 | pagina);   // elige la pagina
        oled_comando(0x00);            // columna baja = 0
        oled_comando(0x10);            // columna alta = 0
        oled_fila(pagina);
    }
}

void app_main(void)
{
    i2c_master_bus_config_t config_bus = {
        .i2c_port = I2C_NUM_0,
        .clk_source = I2C_CLK_SRC_DEFAULT,
        .scl_io_num = PIN_SCL,
        .sda_io_num = PIN_SDA,
        .glitch_ignore_cnt = 7,
        .flags.enable_internal_pullup = true,
    };

    i2c_master_bus_handle_t bus = NULL;
    i2c_new_master_bus(&config_bus, &bus);

    i2c_device_config_t config_oled = {
        .dev_addr_length = I2C_ADDR_BIT_LEN_7,
        .device_address = DIR_OLED,
        .scl_speed_hz = FREC_I2C_HZ,
    };
    i2c_master_bus_add_device(bus, &config_oled, &oled);

    oled_inicializar();
    oled_borrar();
    oled_texto("HOLA DESDE IDF", 0, 0);
    oled_texto("OLED I2C 128x64", 0, 2);
    oled_mostrar();

    printf("OLED I2C listo.\n");

    uint32_t segundos = 0;

    while (1) {
        char linea[21];
        snprintf(linea, sizeof(linea), "TIEMPO: %lu s", segundos);

        // Borra solo la pagina 5 y vuelve a dibujarla
        memset(buffer[5], 0, ANCHO_PX);
        oled_texto(linea, 0, 5);
        oled_mostrar();

        segundos++;
        vTaskDelay(pdMS_TO_TICKS(1000));
    }
}
